DESCRIPTION = "Misc packages for Octoprint image"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = "\
    rpm \
    lrzsz \
    "
