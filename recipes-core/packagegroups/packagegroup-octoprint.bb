DESCRIPTION = "Octoprint packages"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = "\
    octoprint \
    "
